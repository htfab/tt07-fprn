v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {mini_grid.sym} 450 -410 0 0 {name=x1}
C {devices/iopin.sym} 600 -420 0 0 {name=p1 lab=VGND}
C {devices/ipin.sym} 300 -240 0 0 {name=p2 lab=clk}
C {devices/ipin.sym} 320 -720 0 0 {name=p4 lab=ena}
C {ignore.sym} 320 -720 0 0 {name=l1}
C {devices/ipin.sym} 300 -260 0 0 {name=p5 lab=rst_n}
C {devices/ipin.sym} 300 -280 0 0 {name=p6 lab=ui_in[0]}
C {devices/ipin.sym} 300 -360 0 0 {name=p7 lab=ui_in[1]}
C {devices/ipin.sym} 300 -520 0 0 {name=p8 lab=ui_in[2]}
C {devices/ipin.sym} 300 -500 0 0 {name=p9 lab=ui_in[3]}
C {devices/ipin.sym} 300 -480 0 0 {name=p10 lab=ui_in[4]}
C {devices/ipin.sym} 300 -580 0 0 {name=p11 lab=ui_in[5]}
C {devices/ipin.sym} 300 -560 0 0 {name=p12 lab=ui_in[6]}
C {devices/ipin.sym} 300 -540 0 0 {name=p13 lab=ui_in[7]}
C {devices/ipin.sym} 300 -420 0 0 {name=p14 lab=uio_in[0]}
C {devices/ipin.sym} 300 -300 0 0 {name=p15 lab=uio_in[1]}
C {devices/ipin.sym} 300 -380 0 0 {name=p16 lab=uio_in[2]}
C {devices/ipin.sym} 300 -440 0 0 {name=p17 lab=uio_in[3]}
C {devices/ipin.sym} 300 -320 0 0 {name=p18 lab=uio_in[4]}
C {devices/ipin.sym} 300 -400 0 0 {name=p19 lab=uio_in[5]}
C {devices/ipin.sym} 300 -460 0 0 {name=p20 lab=uio_in[6]}
C {devices/ipin.sym} 300 -340 0 0 {name=p21 lab=uio_in[7]}
C {ignore.sym} 600 -540 0 0 {name=l2}
C {ignore.sym} 600 -520 0 0 {name=l3}
C {ignore.sym} 600 -500 0 0 {name=l4}
C {ignore.sym} 600 -480 0 0 {name=l5}
C {ignore.sym} 600 -460 0 0 {name=l6}
C {ignore.sym} 600 -440 0 0 {name=l7}
C {devices/iopin.sym} 600 -580 0 0 {name=p22 lab=VPWR}
C {devices/iopin.sym} 600 -560 0 0 {name=p23 lab=ua[0]}
C {devices/iopin.sym} 780 -510 0 0 {name=p48 lab=ua[1]}
C {devices/iopin.sym} 780 -490 0 0 {name=p49 lab=ua[2]}
C {devices/iopin.sym} 780 -470 0 0 {name=p50 lab=ua[3]}
C {devices/iopin.sym} 780 -450 0 0 {name=p51 lab=ua[4]}
C {devices/iopin.sym} 780 -430 0 0 {name=p52 lab=ua[5]}
C {devices/iopin.sym} 780 -410 0 0 {name=p53 lab=ua[6]}
C {devices/iopin.sym} 780 -390 0 0 {name=p54 lab=ua[7]}
C {ignore.sym} 780 -510 2 0 {name=l8}
C {ignore.sym} 780 -490 2 0 {name=l9}
C {ignore.sym} 780 -470 2 0 {name=l10}
C {ignore.sym} 780 -450 2 0 {name=l11}
C {ignore.sym} 780 -430 2 0 {name=l12}
C {ignore.sym} 780 -410 2 0 {name=l13}
C {ignore.sym} 780 -390 2 0 {name=l14}
