v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 880 -580 920 -580 {
lab=uo_out[0]}
N 920 -580 1040 -580 {
lab=uo_out[0]}
N 920 -580 920 -410 {
lab=uo_out[0]}
N 1040 -580 1040 -410 {
lab=uo_out[0]}
N 1040 -580 1160 -580 {
lab=uo_out[0]}
N 1160 -580 1160 -410 {
lab=uo_out[0]}
C {mini_grid.sym} 450 -410 0 0 {name=x1}
C {devices/iopin.sym} 600 -420 0 0 {name=p1 lab=VGND}
C {devices/ipin.sym} 300 -240 0 0 {name=p2 lab=clk}
C {devices/opin.sym} 920 -550 0 0 {name=p3 lab=uo_out[0]}
C {devices/ipin.sym} 320 -720 0 0 {name=p4 lab=ena}
C {ignore.sym} 320 -720 0 0 {name=l1}
C {devices/ipin.sym} 300 -260 0 0 {name=p5 lab=rst_n}
C {devices/ipin.sym} 300 -280 0 0 {name=p6 lab=ui_in[0]}
C {devices/ipin.sym} 300 -360 0 0 {name=p7 lab=ui_in[1]}
C {devices/ipin.sym} 300 -520 0 0 {name=p8 lab=ui_in[2]}
C {devices/ipin.sym} 300 -500 0 0 {name=p9 lab=ui_in[3]}
C {devices/ipin.sym} 300 -480 0 0 {name=p10 lab=ui_in[4]}
C {devices/ipin.sym} 300 -580 0 0 {name=p11 lab=ui_in[5]}
C {devices/ipin.sym} 300 -560 0 0 {name=p12 lab=ui_in[6]}
C {devices/ipin.sym} 300 -540 0 0 {name=p13 lab=ui_in[7]}
C {devices/ipin.sym} 300 -420 0 0 {name=p14 lab=uio_in[0]}
C {devices/ipin.sym} 300 -300 0 0 {name=p15 lab=uio_in[1]}
C {devices/ipin.sym} 300 -380 0 0 {name=p16 lab=uio_in[2]}
C {devices/ipin.sym} 300 -440 0 0 {name=p17 lab=uio_in[3]}
C {devices/ipin.sym} 300 -320 0 0 {name=p18 lab=uio_in[4]}
C {devices/ipin.sym} 300 -400 0 0 {name=p19 lab=uio_in[5]}
C {devices/ipin.sym} 300 -460 0 0 {name=p20 lab=uio_in[6]}
C {devices/ipin.sym} 300 -340 0 0 {name=p21 lab=uio_in[7]}
C {ignore.sym} 600 -540 0 0 {name=l2}
C {ignore.sym} 600 -520 0 0 {name=l3}
C {ignore.sym} 600 -500 0 0 {name=l4}
C {ignore.sym} 600 -480 0 0 {name=l5}
C {ignore.sym} 600 -460 0 0 {name=l6}
C {ignore.sym} 600 -440 0 0 {name=l7}
C {devices/iopin.sym} 600 -580 0 0 {name=p22 lab=VPWR}
C {devices/iopin.sym} 600 -560 0 0 {name=p23 lab=ua[0]}
C {devices/lab_pin.sym} 880 -580 0 0 {name=p24 sig_type=std_logic lab=VGND}
C {devices/opin.sym} 920 -530 0 0 {name=p25 lab=uo_out[1]}
C {devices/opin.sym} 920 -510 0 0 {name=p26 lab=uo_out[2]}
C {devices/opin.sym} 920 -490 0 0 {name=p27 lab=uo_out[3]}
C {devices/opin.sym} 920 -470 0 0 {name=p28 lab=uo_out[4]}
C {devices/opin.sym} 920 -450 0 0 {name=p29 lab=uo_out[5]}
C {devices/opin.sym} 920 -430 0 0 {name=p30 lab=uo_out[6]}
C {devices/opin.sym} 920 -410 0 0 {name=p31 lab=uo_out[7]}
C {devices/opin.sym} 1040 -550 0 0 {name=p32 lab=uio_out[0]}
C {devices/opin.sym} 1040 -530 0 0 {name=p33 lab=uio_out[1]}
C {devices/opin.sym} 1040 -510 0 0 {name=p34 lab=uio_out[2]}
C {devices/opin.sym} 1040 -490 0 0 {name=p35 lab=uio_out[3]}
C {devices/opin.sym} 1040 -470 0 0 {name=p36 lab=uio_out[4]}
C {devices/opin.sym} 1040 -450 0 0 {name=p37 lab=uio_out[5]}
C {devices/opin.sym} 1040 -430 0 0 {name=p38 lab=uio_out[6]}
C {devices/opin.sym} 1040 -410 0 0 {name=p39 lab=uio_out[7]}
C {devices/opin.sym} 1160 -550 0 0 {name=p40 lab=uio_oe[0]}
C {devices/opin.sym} 1160 -530 0 0 {name=p41 lab=uio_oe[1]}
C {devices/opin.sym} 1160 -510 0 0 {name=p42 lab=uio_oe[2]}
C {devices/opin.sym} 1160 -490 0 0 {name=p43 lab=uio_oe[3]}
C {devices/opin.sym} 1160 -470 0 0 {name=p44 lab=uio_oe[4]}
C {devices/opin.sym} 1160 -450 0 0 {name=p45 lab=uio_oe[5]}
C {devices/opin.sym} 1160 -430 0 0 {name=p46 lab=uio_oe[6]}
C {devices/opin.sym} 1160 -410 0 0 {name=p47 lab=uio_oe[7]}
C {devices/iopin.sym} 780 -510 0 0 {name=p48 lab=ua[1]}
C {devices/iopin.sym} 780 -490 0 0 {name=p49 lab=ua[2]}
C {devices/iopin.sym} 780 -470 0 0 {name=p50 lab=ua[3]}
C {devices/iopin.sym} 780 -450 0 0 {name=p51 lab=ua[4]}
C {devices/iopin.sym} 780 -430 0 0 {name=p52 lab=ua[5]}
C {devices/iopin.sym} 780 -410 0 0 {name=p53 lab=ua[6]}
C {devices/iopin.sym} 780 -390 0 0 {name=p54 lab=ua[7]}
C {ignore.sym} 780 -510 2 0 {name=l8}
C {ignore.sym} 780 -490 2 0 {name=l9}
C {ignore.sym} 780 -470 2 0 {name=l10}
C {ignore.sym} 780 -450 2 0 {name=l11}
C {ignore.sym} 780 -430 2 0 {name=l12}
C {ignore.sym} 780 -410 2 0 {name=l13}
C {ignore.sym} 780 -390 2 0 {name=l14}
