v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {grid_row.sym} 540 -1120 0 0 {name=x1}
C {devices/lab_pin.sym} 390 -870 0 0 {name=p6 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 390 -1370 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 -1370 0 1 {name=p2 sig_type=std_logic lab=V_LINE_0}
C {devices/lab_pin.sym} 690 -1350 0 1 {name=p3 sig_type=std_logic lab=V_LINE_1}
C {devices/lab_pin.sym} 690 -1330 0 1 {name=p4 sig_type=std_logic lab=V_LINE_2}
C {devices/lab_pin.sym} 690 -1310 0 1 {name=p5 sig_type=std_logic lab=V_LINE_3}
C {devices/lab_pin.sym} 690 -1290 0 1 {name=p7 sig_type=std_logic lab=V_LINE_4}
C {devices/lab_pin.sym} 690 -1270 0 1 {name=p8 sig_type=std_logic lab=V_LINE_5}
C {devices/lab_pin.sym} 690 -1250 0 1 {name=p9 sig_type=std_logic lab=V_LINE_6}
C {devices/lab_pin.sym} 690 -1230 0 1 {name=p10 sig_type=std_logic lab=V_LINE_7}
C {devices/lab_pin.sym} 390 -1050 0 0 {name=p11 sig_type=std_logic lab=NODE_00}
C {devices/lab_pin.sym} 390 -1030 0 0 {name=p12 sig_type=std_logic lab=NODE_01}
C {devices/lab_pin.sym} 390 -1010 0 0 {name=p13 sig_type=std_logic lab=NODE_02}
C {devices/lab_pin.sym} 390 -990 0 0 {name=p14 sig_type=std_logic lab=NODE_03}
C {devices/lab_pin.sym} 390 -970 0 0 {name=p15 sig_type=std_logic lab=NODE_04}
C {devices/lab_pin.sym} 390 -950 0 0 {name=p16 sig_type=std_logic lab=NODE_05}
C {devices/lab_pin.sym} 390 -930 0 0 {name=p17 sig_type=std_logic lab=NODE_06}
C {devices/lab_pin.sym} 390 -910 0 0 {name=p18 sig_type=std_logic lab=NODE_07}
C {devices/lab_pin.sym} 390 -890 0 0 {name=p19 sig_type=std_logic lab=NODE_08}
C {devices/lab_pin.sym} 690 -1210 0 1 {name=p20 sig_type=std_logic lab=NODE_10}
C {devices/lab_pin.sym} 690 -1190 0 1 {name=p21 sig_type=std_logic lab=NODE_11}
C {devices/lab_pin.sym} 690 -1170 0 1 {name=p22 sig_type=std_logic lab=NODE_12}
C {devices/lab_pin.sym} 690 -1150 0 1 {name=p23 sig_type=std_logic lab=NODE_13}
C {devices/lab_pin.sym} 690 -1130 0 1 {name=p24 sig_type=std_logic lab=NODE_14}
C {devices/lab_pin.sym} 690 -1110 0 1 {name=p25 sig_type=std_logic lab=NODE_15}
C {devices/lab_pin.sym} 690 -1090 0 1 {name=p26 sig_type=std_logic lab=NODE_16}
C {devices/lab_pin.sym} 690 -1070 0 1 {name=p27 sig_type=std_logic lab=NODE_17}
C {devices/lab_pin.sym} 390 -1350 0 0 {name=p28 sig_type=std_logic lab=V_GATE_BUF_0}
C {devices/lab_pin.sym} 390 -1170 0 0 {name=p29 sig_type=std_logic lab=VD_LINE_BUF}
C {devices/lab_pin.sym} 390 -1150 0 0 {name=p30 sig_type=std_logic lab=VD_SHORT_BUF}
C {devices/lab_pin.sym} 390 -1130 0 0 {name=p31 sig_type=std_logic lab=VD_RES_BUF}
C {devices/lab_pin.sym} 390 -1330 0 0 {name=p32 sig_type=std_logic lab=V_GATE_BUF_1}
C {devices/lab_pin.sym} 390 -1310 0 0 {name=p36 sig_type=std_logic lab=V_GATE_BUF_2}
C {devices/lab_pin.sym} 390 -1290 0 0 {name=p40 sig_type=std_logic lab=V_GATE_BUF_3}
C {devices/lab_pin.sym} 390 -1270 0 0 {name=p44 sig_type=std_logic lab=V_GATE_BUF_4}
C {devices/lab_pin.sym} 390 -1250 0 0 {name=p48 sig_type=std_logic lab=V_GATE_BUF_5}
C {devices/lab_pin.sym} 390 -1230 0 0 {name=p52 sig_type=std_logic lab=V_GATE_BUF_6}
C {devices/lab_pin.sym} 390 -1210 0 0 {name=p56 sig_type=std_logic lab=V_GATE_BUF_7}
C {devices/lab_pin.sym} 390 -1190 0 0 {name=p60 sig_type=std_logic lab=H_GATE_0}
C {devices/lab_pin.sym} 390 -1110 0 0 {name=p61 sig_type=std_logic lab=HD_LINE_BUF}
C {devices/lab_pin.sym} 390 -1090 0 0 {name=p62 sig_type=std_logic lab=HD_SHORT_BUF}
C {devices/lab_pin.sym} 390 -1070 0 0 {name=p63 sig_type=std_logic lab=HD_RES_BUF}
C {grid_row.sym} 1160 -1120 0 0 {name=x2}
C {devices/lab_pin.sym} 1010 -1050 0 0 {name=p83 sig_type=std_logic lab=NODE_10}
C {devices/lab_pin.sym} 1010 -1030 0 0 {name=p84 sig_type=std_logic lab=NODE_11}
C {devices/lab_pin.sym} 1010 -1010 0 0 {name=p85 sig_type=std_logic lab=NODE_12}
C {devices/lab_pin.sym} 1010 -990 0 0 {name=p86 sig_type=std_logic lab=NODE_13}
C {devices/lab_pin.sym} 1010 -970 0 0 {name=p87 sig_type=std_logic lab=NODE_14}
C {devices/lab_pin.sym} 1010 -950 0 0 {name=p88 sig_type=std_logic lab=NODE_15}
C {devices/lab_pin.sym} 1010 -930 0 0 {name=p89 sig_type=std_logic lab=NODE_16}
C {devices/lab_pin.sym} 1010 -910 0 0 {name=p90 sig_type=std_logic lab=NODE_17}
C {grid_row.sym} 1800 -1120 0 0 {name=x3}
C {grid_row.sym} 2440 -1120 0 0 {name=x4}
C {grid_row.sym} 540 -520 0 0 {name=x5}
C {grid_row.sym} 1160 -520 0 0 {name=x6}
C {grid_row.sym} 1800 -520 0 0 {name=x7}
C {grid_row.sym} 2440 -520 0 0 {name=x8}
C {devices/lab_pin.sym} 1010 -890 0 0 {name=p74 sig_type=std_logic lab=NODE_18}
C {devices/lab_pin.sym} 1310 -1210 0 1 {name=p394 sig_type=std_logic lab=NODE_20}
C {devices/lab_pin.sym} 1310 -1190 0 1 {name=p395 sig_type=std_logic lab=NODE_21}
C {devices/lab_pin.sym} 1310 -1170 0 1 {name=p396 sig_type=std_logic lab=NODE_22}
C {devices/lab_pin.sym} 1310 -1150 0 1 {name=p397 sig_type=std_logic lab=NODE_23}
C {devices/lab_pin.sym} 1310 -1130 0 1 {name=p398 sig_type=std_logic lab=NODE_24}
C {devices/lab_pin.sym} 1310 -1110 0 1 {name=p399 sig_type=std_logic lab=NODE_25}
C {devices/lab_pin.sym} 1310 -1090 0 1 {name=p400 sig_type=std_logic lab=NODE_26}
C {devices/lab_pin.sym} 1310 -1070 0 1 {name=p401 sig_type=std_logic lab=NODE_27}
C {devices/lab_pin.sym} 1950 -1210 0 1 {name=p403 sig_type=std_logic lab=NODE_30}
C {devices/lab_pin.sym} 1950 -1190 0 1 {name=p404 sig_type=std_logic lab=NODE_31}
C {devices/lab_pin.sym} 1950 -1170 0 1 {name=p405 sig_type=std_logic lab=NODE_32}
C {devices/lab_pin.sym} 1950 -1150 0 1 {name=p452 sig_type=std_logic lab=NODE_33}
C {devices/lab_pin.sym} 1950 -1130 0 1 {name=p453 sig_type=std_logic lab=NODE_34}
C {devices/lab_pin.sym} 1950 -1110 0 1 {name=p454 sig_type=std_logic lab=NODE_35}
C {devices/lab_pin.sym} 1950 -1090 0 1 {name=p455 sig_type=std_logic lab=NODE_36}
C {devices/lab_pin.sym} 1950 -1070 0 1 {name=p456 sig_type=std_logic lab=NODE_37}
C {devices/lab_pin.sym} 2590 -1210 0 1 {name=p458 sig_type=std_logic lab=NODE_40}
C {devices/lab_pin.sym} 2590 -1190 0 1 {name=p459 sig_type=std_logic lab=NODE_41}
C {devices/lab_pin.sym} 2590 -1170 0 1 {name=p460 sig_type=std_logic lab=NODE_42}
C {devices/lab_pin.sym} 2590 -1150 0 1 {name=p461 sig_type=std_logic lab=NODE_43}
C {devices/lab_pin.sym} 2590 -1130 0 1 {name=p462 sig_type=std_logic lab=NODE_44}
C {devices/lab_pin.sym} 2590 -1110 0 1 {name=p463 sig_type=std_logic lab=NODE_45}
C {devices/lab_pin.sym} 2590 -1090 0 1 {name=p464 sig_type=std_logic lab=NODE_46}
C {devices/lab_pin.sym} 2590 -1070 0 1 {name=p465 sig_type=std_logic lab=NODE_47}
C {devices/lab_pin.sym} 690 -610 0 1 {name=p467 sig_type=std_logic lab=NODE_50}
C {devices/lab_pin.sym} 690 -590 0 1 {name=p468 sig_type=std_logic lab=NODE_51}
C {devices/lab_pin.sym} 690 -570 0 1 {name=p505 sig_type=std_logic lab=NODE_52}
C {devices/lab_pin.sym} 690 -550 0 1 {name=p506 sig_type=std_logic lab=NODE_53}
C {devices/lab_pin.sym} 690 -530 0 1 {name=p507 sig_type=std_logic lab=NODE_54}
C {devices/lab_pin.sym} 690 -510 0 1 {name=p508 sig_type=std_logic lab=NODE_55}
C {devices/lab_pin.sym} 690 -490 0 1 {name=p509 sig_type=std_logic lab=NODE_56}
C {devices/lab_pin.sym} 690 -470 0 1 {name=p510 sig_type=std_logic lab=NODE_57}
C {devices/lab_pin.sym} 1310 -610 0 1 {name=p512 sig_type=std_logic lab=NODE_60}
C {devices/lab_pin.sym} 1310 -590 0 1 {name=p513 sig_type=std_logic lab=NODE_61}
C {devices/lab_pin.sym} 1310 -570 0 1 {name=p514 sig_type=std_logic lab=NODE_62}
C {devices/lab_pin.sym} 1310 -550 0 1 {name=p515 sig_type=std_logic lab=NODE_63}
C {devices/lab_pin.sym} 1310 -530 0 1 {name=p516 sig_type=std_logic lab=NODE_64}
C {devices/lab_pin.sym} 1310 -510 0 1 {name=p517 sig_type=std_logic lab=NODE_65}
C {devices/lab_pin.sym} 1310 -490 0 1 {name=p518 sig_type=std_logic lab=NODE_66}
C {devices/lab_pin.sym} 1310 -470 0 1 {name=p519 sig_type=std_logic lab=NODE_67}
C {devices/lab_pin.sym} 1950 -610 0 1 {name=p521 sig_type=std_logic lab=NODE_70}
C {devices/lab_pin.sym} 1950 -590 0 1 {name=p522 sig_type=std_logic lab=NODE_71}
C {devices/lab_pin.sym} 1950 -570 0 1 {name=p523 sig_type=std_logic lab=NODE_72}
C {devices/lab_pin.sym} 1950 -550 0 1 {name=p524 sig_type=std_logic lab=NODE_73}
C {devices/lab_pin.sym} 1950 -530 0 1 {name=p525 sig_type=std_logic lab=NODE_74}
C {devices/lab_pin.sym} 1950 -510 0 1 {name=p526 sig_type=std_logic lab=NODE_75}
C {devices/lab_pin.sym} 1950 -490 0 1 {name=p527 sig_type=std_logic lab=NODE_76}
C {devices/lab_pin.sym} 1950 -470 0 1 {name=p528 sig_type=std_logic lab=NODE_77}
C {devices/lab_pin.sym} 2590 -610 0 1 {name=p530 sig_type=std_logic lab=NODE_80}
C {devices/lab_pin.sym} 2590 -590 0 1 {name=p531 sig_type=std_logic lab=NODE_81}
C {devices/lab_pin.sym} 2590 -570 0 1 {name=p532 sig_type=std_logic lab=NODE_82}
C {devices/lab_pin.sym} 2590 -550 0 1 {name=p533 sig_type=std_logic lab=NODE_83}
C {devices/lab_pin.sym} 2590 -530 0 1 {name=p534 sig_type=std_logic lab=NODE_84}
C {devices/lab_pin.sym} 2590 -510 0 1 {name=p535 sig_type=std_logic lab=NODE_85}
C {devices/lab_pin.sym} 2590 -490 0 1 {name=p536 sig_type=std_logic lab=NODE_86}
C {devices/lab_pin.sym} 2590 -470 0 1 {name=p537 sig_type=std_logic lab=NODE_87}
C {devices/lab_pin.sym} 1650 -1050 0 0 {name=p75 sig_type=std_logic lab=NODE_20}
C {devices/lab_pin.sym} 1650 -1030 0 0 {name=p76 sig_type=std_logic lab=NODE_21}
C {devices/lab_pin.sym} 1650 -1010 0 0 {name=p77 sig_type=std_logic lab=NODE_22}
C {devices/lab_pin.sym} 1650 -990 0 0 {name=p78 sig_type=std_logic lab=NODE_23}
C {devices/lab_pin.sym} 1650 -970 0 0 {name=p79 sig_type=std_logic lab=NODE_24}
C {devices/lab_pin.sym} 1650 -950 0 0 {name=p80 sig_type=std_logic lab=NODE_25}
C {devices/lab_pin.sym} 1650 -930 0 0 {name=p81 sig_type=std_logic lab=NODE_26}
C {devices/lab_pin.sym} 1650 -910 0 0 {name=p82 sig_type=std_logic lab=NODE_27}
C {devices/lab_pin.sym} 1650 -890 0 0 {name=p137 sig_type=std_logic lab=NODE_28}
C {devices/lab_pin.sym} 2290 -1050 0 0 {name=p138 sig_type=std_logic lab=NODE_30}
C {devices/lab_pin.sym} 2290 -1030 0 0 {name=p139 sig_type=std_logic lab=NODE_31}
C {devices/lab_pin.sym} 2290 -1010 0 0 {name=p140 sig_type=std_logic lab=NODE_32}
C {devices/lab_pin.sym} 2290 -990 0 0 {name=p141 sig_type=std_logic lab=NODE_33}
C {devices/lab_pin.sym} 2290 -970 0 0 {name=p142 sig_type=std_logic lab=NODE_34}
C {devices/lab_pin.sym} 2290 -950 0 0 {name=p143 sig_type=std_logic lab=NODE_35}
C {devices/lab_pin.sym} 2290 -930 0 0 {name=p144 sig_type=std_logic lab=NODE_36}
C {devices/lab_pin.sym} 2290 -910 0 0 {name=p145 sig_type=std_logic lab=NODE_37}
C {devices/lab_pin.sym} 2290 -890 0 0 {name=p146 sig_type=std_logic lab=NODE_38}
C {devices/lab_pin.sym} 390 -450 0 0 {name=p147 sig_type=std_logic lab=NODE_40}
C {devices/lab_pin.sym} 390 -430 0 0 {name=p148 sig_type=std_logic lab=NODE_41}
C {devices/lab_pin.sym} 390 -410 0 0 {name=p149 sig_type=std_logic lab=NODE_42}
C {devices/lab_pin.sym} 390 -390 0 0 {name=p150 sig_type=std_logic lab=NODE_43}
C {devices/lab_pin.sym} 390 -370 0 0 {name=p151 sig_type=std_logic lab=NODE_44}
C {devices/lab_pin.sym} 390 -350 0 0 {name=p152 sig_type=std_logic lab=NODE_45}
C {devices/lab_pin.sym} 390 -330 0 0 {name=p153 sig_type=std_logic lab=NODE_46}
C {devices/lab_pin.sym} 390 -310 0 0 {name=p200 sig_type=std_logic lab=NODE_47}
C {devices/lab_pin.sym} 390 -290 0 0 {name=p201 sig_type=std_logic lab=NODE_48}
C {devices/lab_pin.sym} 1010 -450 0 0 {name=p202 sig_type=std_logic lab=NODE_50}
C {devices/lab_pin.sym} 1010 -430 0 0 {name=p203 sig_type=std_logic lab=NODE_51}
C {devices/lab_pin.sym} 1010 -410 0 0 {name=p204 sig_type=std_logic lab=NODE_52}
C {devices/lab_pin.sym} 1010 -390 0 0 {name=p205 sig_type=std_logic lab=NODE_53}
C {devices/lab_pin.sym} 1010 -370 0 0 {name=p206 sig_type=std_logic lab=NODE_54}
C {devices/lab_pin.sym} 1010 -350 0 0 {name=p207 sig_type=std_logic lab=NODE_55}
C {devices/lab_pin.sym} 1010 -330 0 0 {name=p208 sig_type=std_logic lab=NODE_56}
C {devices/lab_pin.sym} 1010 -310 0 0 {name=p209 sig_type=std_logic lab=NODE_57}
C {devices/lab_pin.sym} 1010 -290 0 0 {name=p210 sig_type=std_logic lab=NODE_58}
C {devices/lab_pin.sym} 1650 -450 0 0 {name=p211 sig_type=std_logic lab=NODE_60}
C {devices/lab_pin.sym} 1650 -430 0 0 {name=p212 sig_type=std_logic lab=NODE_61}
C {devices/lab_pin.sym} 1650 -410 0 0 {name=p213 sig_type=std_logic lab=NODE_62}
C {devices/lab_pin.sym} 1650 -390 0 0 {name=p214 sig_type=std_logic lab=NODE_63}
C {devices/lab_pin.sym} 1650 -370 0 0 {name=p215 sig_type=std_logic lab=NODE_64}
C {devices/lab_pin.sym} 1650 -350 0 0 {name=p216 sig_type=std_logic lab=NODE_65}
C {devices/lab_pin.sym} 1650 -330 0 0 {name=p263 sig_type=std_logic lab=NODE_66}
C {devices/lab_pin.sym} 1650 -310 0 0 {name=p264 sig_type=std_logic lab=NODE_67}
C {devices/lab_pin.sym} 1650 -290 0 0 {name=p265 sig_type=std_logic lab=NODE_68}
C {devices/lab_pin.sym} 2290 -450 0 0 {name=p266 sig_type=std_logic lab=NODE_70}
C {devices/lab_pin.sym} 2290 -430 0 0 {name=p267 sig_type=std_logic lab=NODE_71}
C {devices/lab_pin.sym} 2290 -410 0 0 {name=p268 sig_type=std_logic lab=NODE_72}
C {devices/lab_pin.sym} 2290 -390 0 0 {name=p269 sig_type=std_logic lab=NODE_73}
C {devices/lab_pin.sym} 2290 -370 0 0 {name=p270 sig_type=std_logic lab=NODE_74}
C {devices/lab_pin.sym} 2290 -350 0 0 {name=p271 sig_type=std_logic lab=NODE_75}
C {devices/lab_pin.sym} 2290 -330 0 0 {name=p272 sig_type=std_logic lab=NODE_76}
C {devices/lab_pin.sym} 2290 -310 0 0 {name=p273 sig_type=std_logic lab=NODE_77}
C {devices/lab_pin.sym} 2290 -290 0 0 {name=p274 sig_type=std_logic lab=NODE_78}
C {devices/lab_pin.sym} 1010 -870 0 0 {name=p33 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1010 -1370 0 0 {name=p34 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1310 -1370 0 1 {name=p35 sig_type=std_logic lab=V_LINE_0}
C {devices/lab_pin.sym} 1310 -1350 0 1 {name=p37 sig_type=std_logic lab=V_LINE_1}
C {devices/lab_pin.sym} 1310 -1330 0 1 {name=p38 sig_type=std_logic lab=V_LINE_2}
C {devices/lab_pin.sym} 1310 -1310 0 1 {name=p39 sig_type=std_logic lab=V_LINE_3}
C {devices/lab_pin.sym} 1310 -1290 0 1 {name=p41 sig_type=std_logic lab=V_LINE_4}
C {devices/lab_pin.sym} 1310 -1270 0 1 {name=p42 sig_type=std_logic lab=V_LINE_5}
C {devices/lab_pin.sym} 1310 -1250 0 1 {name=p43 sig_type=std_logic lab=V_LINE_6}
C {devices/lab_pin.sym} 1310 -1230 0 1 {name=p45 sig_type=std_logic lab=V_LINE_7}
C {devices/lab_pin.sym} 1010 -1350 0 0 {name=p46 sig_type=std_logic lab=V_GATE_BUF_0}
C {devices/lab_pin.sym} 1010 -1170 0 0 {name=p47 sig_type=std_logic lab=VD_LINE_BUF}
C {devices/lab_pin.sym} 1010 -1150 0 0 {name=p49 sig_type=std_logic lab=VD_SHORT_BUF}
C {devices/lab_pin.sym} 1010 -1130 0 0 {name=p50 sig_type=std_logic lab=VD_RES_BUF}
C {devices/lab_pin.sym} 1010 -1330 0 0 {name=p51 sig_type=std_logic lab=V_GATE_BUF_1}
C {devices/lab_pin.sym} 1010 -1310 0 0 {name=p53 sig_type=std_logic lab=V_GATE_BUF_2}
C {devices/lab_pin.sym} 1010 -1290 0 0 {name=p54 sig_type=std_logic lab=V_GATE_BUF_3}
C {devices/lab_pin.sym} 1010 -1270 0 0 {name=p55 sig_type=std_logic lab=V_GATE_BUF_4}
C {devices/lab_pin.sym} 1010 -1250 0 0 {name=p57 sig_type=std_logic lab=V_GATE_BUF_5}
C {devices/lab_pin.sym} 1010 -1230 0 0 {name=p58 sig_type=std_logic lab=V_GATE_BUF_6}
C {devices/lab_pin.sym} 1010 -1210 0 0 {name=p59 sig_type=std_logic lab=V_GATE_BUF_7}
C {devices/lab_pin.sym} 1010 -1190 0 0 {name=p64 sig_type=std_logic lab=H_GATE_1}
C {devices/lab_pin.sym} 1010 -1110 0 0 {name=p65 sig_type=std_logic lab=HD_LINE_BUF}
C {devices/lab_pin.sym} 1010 -1090 0 0 {name=p66 sig_type=std_logic lab=HD_SHORT_BUF}
C {devices/lab_pin.sym} 1010 -1070 0 0 {name=p67 sig_type=std_logic lab=HD_RES_BUF}
C {devices/lab_pin.sym} 1650 -870 0 0 {name=p68 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1650 -1370 0 0 {name=p69 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1950 -1370 0 1 {name=p70 sig_type=std_logic lab=V_LINE_0}
C {devices/lab_pin.sym} 1950 -1350 0 1 {name=p71 sig_type=std_logic lab=V_LINE_1}
C {devices/lab_pin.sym} 1950 -1330 0 1 {name=p72 sig_type=std_logic lab=V_LINE_2}
C {devices/lab_pin.sym} 1950 -1310 0 1 {name=p73 sig_type=std_logic lab=V_LINE_3}
C {devices/lab_pin.sym} 1950 -1290 0 1 {name=p91 sig_type=std_logic lab=V_LINE_4}
C {devices/lab_pin.sym} 1950 -1270 0 1 {name=p92 sig_type=std_logic lab=V_LINE_5}
C {devices/lab_pin.sym} 1950 -1250 0 1 {name=p93 sig_type=std_logic lab=V_LINE_6}
C {devices/lab_pin.sym} 1950 -1230 0 1 {name=p94 sig_type=std_logic lab=V_LINE_7}
C {devices/lab_pin.sym} 1650 -1350 0 0 {name=p95 sig_type=std_logic lab=V_GATE_BUF_0}
C {devices/lab_pin.sym} 1650 -1170 0 0 {name=p96 sig_type=std_logic lab=VD_LINE_BUF}
C {devices/lab_pin.sym} 1650 -1150 0 0 {name=p97 sig_type=std_logic lab=VD_SHORT_BUF}
C {devices/lab_pin.sym} 1650 -1130 0 0 {name=p98 sig_type=std_logic lab=VD_RES_BUF}
C {devices/lab_pin.sym} 1650 -1330 0 0 {name=p99 sig_type=std_logic lab=V_GATE_BUF_1}
C {devices/lab_pin.sym} 1650 -1310 0 0 {name=p100 sig_type=std_logic lab=V_GATE_BUF_2}
C {devices/lab_pin.sym} 1650 -1290 0 0 {name=p101 sig_type=std_logic lab=V_GATE_BUF_3}
C {devices/lab_pin.sym} 1650 -1270 0 0 {name=p102 sig_type=std_logic lab=V_GATE_BUF_4}
C {devices/lab_pin.sym} 1650 -1250 0 0 {name=p103 sig_type=std_logic lab=V_GATE_BUF_5}
C {devices/lab_pin.sym} 1650 -1230 0 0 {name=p104 sig_type=std_logic lab=V_GATE_BUF_6}
C {devices/lab_pin.sym} 1650 -1210 0 0 {name=p105 sig_type=std_logic lab=V_GATE_BUF_7}
C {devices/lab_pin.sym} 1650 -1190 0 0 {name=p106 sig_type=std_logic lab=H_GATE_2}
C {devices/lab_pin.sym} 1650 -1110 0 0 {name=p107 sig_type=std_logic lab=HD_LINE_BUF}
C {devices/lab_pin.sym} 1650 -1090 0 0 {name=p108 sig_type=std_logic lab=HD_SHORT_BUF}
C {devices/lab_pin.sym} 1650 -1070 0 0 {name=p109 sig_type=std_logic lab=HD_RES_BUF}
C {devices/lab_pin.sym} 2290 -870 0 0 {name=p110 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -1370 0 0 {name=p111 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2590 -1370 0 1 {name=p112 sig_type=std_logic lab=V_LINE_0}
C {devices/lab_pin.sym} 2590 -1350 0 1 {name=p113 sig_type=std_logic lab=V_LINE_1}
C {devices/lab_pin.sym} 2590 -1330 0 1 {name=p114 sig_type=std_logic lab=V_LINE_2}
C {devices/lab_pin.sym} 2590 -1310 0 1 {name=p115 sig_type=std_logic lab=V_LINE_3}
C {devices/lab_pin.sym} 2590 -1290 0 1 {name=p116 sig_type=std_logic lab=V_LINE_4}
C {devices/lab_pin.sym} 2590 -1270 0 1 {name=p117 sig_type=std_logic lab=V_LINE_5}
C {devices/lab_pin.sym} 2590 -1250 0 1 {name=p118 sig_type=std_logic lab=V_LINE_6}
C {devices/lab_pin.sym} 2590 -1230 0 1 {name=p119 sig_type=std_logic lab=V_LINE_7}
C {devices/lab_pin.sym} 2290 -1350 0 0 {name=p120 sig_type=std_logic lab=V_GATE_BUF_0}
C {devices/lab_pin.sym} 2290 -1170 0 0 {name=p121 sig_type=std_logic lab=VD_LINE_BUF}
C {devices/lab_pin.sym} 2290 -1150 0 0 {name=p122 sig_type=std_logic lab=VD_SHORT_BUF}
C {devices/lab_pin.sym} 2290 -1130 0 0 {name=p123 sig_type=std_logic lab=VD_RES_BUF}
C {devices/lab_pin.sym} 2290 -1330 0 0 {name=p124 sig_type=std_logic lab=V_GATE_BUF_1}
C {devices/lab_pin.sym} 2290 -1310 0 0 {name=p125 sig_type=std_logic lab=V_GATE_BUF_2}
C {devices/lab_pin.sym} 2290 -1290 0 0 {name=p126 sig_type=std_logic lab=V_GATE_BUF_3}
C {devices/lab_pin.sym} 2290 -1270 0 0 {name=p127 sig_type=std_logic lab=V_GATE_BUF_4}
C {devices/lab_pin.sym} 2290 -1250 0 0 {name=p128 sig_type=std_logic lab=V_GATE_BUF_5}
C {devices/lab_pin.sym} 2290 -1230 0 0 {name=p129 sig_type=std_logic lab=V_GATE_BUF_6}
C {devices/lab_pin.sym} 2290 -1210 0 0 {name=p130 sig_type=std_logic lab=V_GATE_BUF_7}
C {devices/lab_pin.sym} 2290 -1190 0 0 {name=p131 sig_type=std_logic lab=H_GATE_3}
C {devices/lab_pin.sym} 2290 -1110 0 0 {name=p132 sig_type=std_logic lab=HD_LINE_BUF}
C {devices/lab_pin.sym} 2290 -1090 0 0 {name=p133 sig_type=std_logic lab=HD_SHORT_BUF}
C {devices/lab_pin.sym} 2290 -1070 0 0 {name=p134 sig_type=std_logic lab=HD_RES_BUF}
C {devices/lab_pin.sym} 390 -270 0 0 {name=p135 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 390 -770 0 0 {name=p136 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 -770 0 1 {name=p154 sig_type=std_logic lab=V_LINE_0}
C {devices/lab_pin.sym} 690 -750 0 1 {name=p155 sig_type=std_logic lab=V_LINE_1}
C {devices/lab_pin.sym} 690 -730 0 1 {name=p156 sig_type=std_logic lab=V_LINE_2}
C {devices/lab_pin.sym} 690 -710 0 1 {name=p157 sig_type=std_logic lab=V_LINE_3}
C {devices/lab_pin.sym} 690 -690 0 1 {name=p158 sig_type=std_logic lab=V_LINE_4}
C {devices/lab_pin.sym} 690 -670 0 1 {name=p159 sig_type=std_logic lab=V_LINE_5}
C {devices/lab_pin.sym} 690 -650 0 1 {name=p160 sig_type=std_logic lab=V_LINE_6}
C {devices/lab_pin.sym} 690 -630 0 1 {name=p161 sig_type=std_logic lab=V_LINE_7}
C {devices/lab_pin.sym} 390 -750 0 0 {name=p162 sig_type=std_logic lab=V_GATE_BUF_0}
C {devices/lab_pin.sym} 390 -570 0 0 {name=p163 sig_type=std_logic lab=VD_LINE_BUF}
C {devices/lab_pin.sym} 390 -550 0 0 {name=p164 sig_type=std_logic lab=VD_SHORT_BUF}
C {devices/lab_pin.sym} 390 -530 0 0 {name=p165 sig_type=std_logic lab=VD_RES_BUF}
C {devices/lab_pin.sym} 390 -730 0 0 {name=p166 sig_type=std_logic lab=V_GATE_BUF_1}
C {devices/lab_pin.sym} 390 -710 0 0 {name=p167 sig_type=std_logic lab=V_GATE_BUF_2}
C {devices/lab_pin.sym} 390 -690 0 0 {name=p168 sig_type=std_logic lab=V_GATE_BUF_3}
C {devices/lab_pin.sym} 390 -670 0 0 {name=p169 sig_type=std_logic lab=V_GATE_BUF_4}
C {devices/lab_pin.sym} 390 -650 0 0 {name=p170 sig_type=std_logic lab=V_GATE_BUF_5}
C {devices/lab_pin.sym} 390 -630 0 0 {name=p171 sig_type=std_logic lab=V_GATE_BUF_6}
C {devices/lab_pin.sym} 390 -610 0 0 {name=p172 sig_type=std_logic lab=V_GATE_BUF_7}
C {devices/lab_pin.sym} 390 -590 0 0 {name=p173 sig_type=std_logic lab=H_GATE_4}
C {devices/lab_pin.sym} 390 -510 0 0 {name=p174 sig_type=std_logic lab=HD_LINE_BUF}
C {devices/lab_pin.sym} 390 -490 0 0 {name=p175 sig_type=std_logic lab=HD_SHORT_BUF}
C {devices/lab_pin.sym} 390 -470 0 0 {name=p176 sig_type=std_logic lab=HD_RES_BUF}
C {devices/lab_pin.sym} 1010 -270 0 0 {name=p177 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1010 -770 0 0 {name=p178 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1310 -770 0 1 {name=p179 sig_type=std_logic lab=V_LINE_0}
C {devices/lab_pin.sym} 1310 -750 0 1 {name=p180 sig_type=std_logic lab=V_LINE_1}
C {devices/lab_pin.sym} 1310 -730 0 1 {name=p181 sig_type=std_logic lab=V_LINE_2}
C {devices/lab_pin.sym} 1310 -710 0 1 {name=p182 sig_type=std_logic lab=V_LINE_3}
C {devices/lab_pin.sym} 1310 -690 0 1 {name=p183 sig_type=std_logic lab=V_LINE_4}
C {devices/lab_pin.sym} 1310 -670 0 1 {name=p184 sig_type=std_logic lab=V_LINE_5}
C {devices/lab_pin.sym} 1310 -650 0 1 {name=p185 sig_type=std_logic lab=V_LINE_6}
C {devices/lab_pin.sym} 1310 -630 0 1 {name=p186 sig_type=std_logic lab=V_LINE_7}
C {devices/lab_pin.sym} 1010 -750 0 0 {name=p187 sig_type=std_logic lab=V_GATE_BUF_0}
C {devices/lab_pin.sym} 1010 -570 0 0 {name=p188 sig_type=std_logic lab=VD_LINE_BUF}
C {devices/lab_pin.sym} 1010 -550 0 0 {name=p189 sig_type=std_logic lab=VD_SHORT_BUF}
C {devices/lab_pin.sym} 1010 -530 0 0 {name=p190 sig_type=std_logic lab=VD_RES_BUF}
C {devices/lab_pin.sym} 1010 -730 0 0 {name=p191 sig_type=std_logic lab=V_GATE_BUF_1}
C {devices/lab_pin.sym} 1010 -710 0 0 {name=p192 sig_type=std_logic lab=V_GATE_BUF_2}
C {devices/lab_pin.sym} 1010 -690 0 0 {name=p193 sig_type=std_logic lab=V_GATE_BUF_3}
C {devices/lab_pin.sym} 1010 -670 0 0 {name=p194 sig_type=std_logic lab=V_GATE_BUF_4}
C {devices/lab_pin.sym} 1010 -650 0 0 {name=p195 sig_type=std_logic lab=V_GATE_BUF_5}
C {devices/lab_pin.sym} 1010 -630 0 0 {name=p196 sig_type=std_logic lab=V_GATE_BUF_6}
C {devices/lab_pin.sym} 1010 -610 0 0 {name=p197 sig_type=std_logic lab=V_GATE_BUF_7}
C {devices/lab_pin.sym} 1010 -590 0 0 {name=p198 sig_type=std_logic lab=H_GATE_5}
C {devices/lab_pin.sym} 1010 -510 0 0 {name=p199 sig_type=std_logic lab=HD_LINE_BUF}
C {devices/lab_pin.sym} 1010 -490 0 0 {name=p217 sig_type=std_logic lab=HD_SHORT_BUF}
C {devices/lab_pin.sym} 1010 -470 0 0 {name=p218 sig_type=std_logic lab=HD_RES_BUF}
C {devices/lab_pin.sym} 1650 -270 0 0 {name=p219 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1650 -770 0 0 {name=p220 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1950 -770 0 1 {name=p221 sig_type=std_logic lab=V_LINE_0}
C {devices/lab_pin.sym} 1950 -750 0 1 {name=p222 sig_type=std_logic lab=V_LINE_1}
C {devices/lab_pin.sym} 1950 -730 0 1 {name=p223 sig_type=std_logic lab=V_LINE_2}
C {devices/lab_pin.sym} 1950 -710 0 1 {name=p224 sig_type=std_logic lab=V_LINE_3}
C {devices/lab_pin.sym} 1950 -690 0 1 {name=p225 sig_type=std_logic lab=V_LINE_4}
C {devices/lab_pin.sym} 1950 -670 0 1 {name=p226 sig_type=std_logic lab=V_LINE_5}
C {devices/lab_pin.sym} 1950 -650 0 1 {name=p227 sig_type=std_logic lab=V_LINE_6}
C {devices/lab_pin.sym} 1950 -630 0 1 {name=p228 sig_type=std_logic lab=V_LINE_7}
C {devices/lab_pin.sym} 1650 -750 0 0 {name=p229 sig_type=std_logic lab=V_GATE_BUF_0}
C {devices/lab_pin.sym} 1650 -570 0 0 {name=p230 sig_type=std_logic lab=VD_LINE_BUF}
C {devices/lab_pin.sym} 1650 -550 0 0 {name=p231 sig_type=std_logic lab=VD_SHORT_BUF}
C {devices/lab_pin.sym} 1650 -530 0 0 {name=p232 sig_type=std_logic lab=VD_RES_BUF}
C {devices/lab_pin.sym} 1650 -730 0 0 {name=p233 sig_type=std_logic lab=V_GATE_BUF_1}
C {devices/lab_pin.sym} 1650 -710 0 0 {name=p234 sig_type=std_logic lab=V_GATE_BUF_2}
C {devices/lab_pin.sym} 1650 -690 0 0 {name=p235 sig_type=std_logic lab=V_GATE_BUF_3}
C {devices/lab_pin.sym} 1650 -670 0 0 {name=p236 sig_type=std_logic lab=V_GATE_BUF_4}
C {devices/lab_pin.sym} 1650 -650 0 0 {name=p237 sig_type=std_logic lab=V_GATE_BUF_5}
C {devices/lab_pin.sym} 1650 -630 0 0 {name=p238 sig_type=std_logic lab=V_GATE_BUF_6}
C {devices/lab_pin.sym} 1650 -610 0 0 {name=p239 sig_type=std_logic lab=V_GATE_BUF_7}
C {devices/lab_pin.sym} 1650 -590 0 0 {name=p240 sig_type=std_logic lab=H_GATE_6}
C {devices/lab_pin.sym} 1650 -510 0 0 {name=p241 sig_type=std_logic lab=HD_LINE_BUF}
C {devices/lab_pin.sym} 1650 -490 0 0 {name=p242 sig_type=std_logic lab=HD_SHORT_BUF}
C {devices/lab_pin.sym} 1650 -470 0 0 {name=p243 sig_type=std_logic lab=HD_RES_BUF}
C {devices/lab_pin.sym} 2290 -270 0 0 {name=p244 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -770 0 0 {name=p245 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2590 -770 0 1 {name=p246 sig_type=std_logic lab=V_LINE_0}
C {devices/lab_pin.sym} 2590 -750 0 1 {name=p247 sig_type=std_logic lab=V_LINE_1}
C {devices/lab_pin.sym} 2590 -730 0 1 {name=p248 sig_type=std_logic lab=V_LINE_2}
C {devices/lab_pin.sym} 2590 -710 0 1 {name=p249 sig_type=std_logic lab=V_LINE_3}
C {devices/lab_pin.sym} 2590 -690 0 1 {name=p250 sig_type=std_logic lab=V_LINE_4}
C {devices/lab_pin.sym} 2590 -670 0 1 {name=p251 sig_type=std_logic lab=V_LINE_5}
C {devices/lab_pin.sym} 2590 -650 0 1 {name=p252 sig_type=std_logic lab=V_LINE_6}
C {devices/lab_pin.sym} 2590 -630 0 1 {name=p253 sig_type=std_logic lab=V_LINE_7}
C {devices/lab_pin.sym} 2290 -750 0 0 {name=p254 sig_type=std_logic lab=V_GATE_BUF_0}
C {devices/lab_pin.sym} 2290 -570 0 0 {name=p255 sig_type=std_logic lab=VD_LINE_BUF}
C {devices/lab_pin.sym} 2290 -550 0 0 {name=p256 sig_type=std_logic lab=VD_SHORT_BUF}
C {devices/lab_pin.sym} 2290 -530 0 0 {name=p257 sig_type=std_logic lab=VD_RES_BUF}
C {devices/lab_pin.sym} 2290 -730 0 0 {name=p258 sig_type=std_logic lab=V_GATE_BUF_1}
C {devices/lab_pin.sym} 2290 -710 0 0 {name=p259 sig_type=std_logic lab=V_GATE_BUF_2}
C {devices/lab_pin.sym} 2290 -690 0 0 {name=p260 sig_type=std_logic lab=V_GATE_BUF_3}
C {devices/lab_pin.sym} 2290 -670 0 0 {name=p261 sig_type=std_logic lab=V_GATE_BUF_4}
C {devices/lab_pin.sym} 2290 -650 0 0 {name=p262 sig_type=std_logic lab=V_GATE_BUF_5}
C {devices/lab_pin.sym} 2290 -630 0 0 {name=p280 sig_type=std_logic lab=V_GATE_BUF_6}
C {devices/lab_pin.sym} 2290 -610 0 0 {name=p281 sig_type=std_logic lab=V_GATE_BUF_7}
C {devices/lab_pin.sym} 2290 -590 0 0 {name=p282 sig_type=std_logic lab=H_GATE_7}
C {devices/lab_pin.sym} 2290 -510 0 0 {name=p283 sig_type=std_logic lab=HD_LINE_BUF}
C {devices/lab_pin.sym} 2290 -490 0 0 {name=p284 sig_type=std_logic lab=HD_SHORT_BUF}
C {devices/lab_pin.sym} 2290 -470 0 0 {name=p285 sig_type=std_logic lab=HD_RES_BUF}
C {buffer.sym} 2440 -1490 0 0 {name=x9}
C {buffer.sym} 2440 -1570 0 0 {name=x10}
C {buffer.sym} 2440 -1650 0 0 {name=x11}
C {devices/lab_pin.sym} 2290 -1470 0 0 {name=p278 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -1550 0 0 {name=p279 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -1630 0 0 {name=p286 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -1510 0 0 {name=p287 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2290 -1590 0 0 {name=p288 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2290 -1670 0 0 {name=p289 sig_type=std_logic lab=VDD}
C {buffer.sym} 2440 -1730 0 0 {name=x12}
C {buffer.sym} 2440 -1810 0 0 {name=x13}
C {buffer.sym} 2440 -1890 0 0 {name=x14}
C {devices/lab_pin.sym} 2290 -1710 0 0 {name=p296 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -1790 0 0 {name=p297 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -1870 0 0 {name=p298 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -1750 0 0 {name=p299 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2290 -1830 0 0 {name=p300 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2290 -1910 0 0 {name=p301 sig_type=std_logic lab=VDD}
C {buffer.sym} 2440 -1970 0 0 {name=x15}
C {devices/lab_pin.sym} 2290 -1950 0 0 {name=p306 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -1990 0 0 {name=p307 sig_type=std_logic lab=VDD}
C {buffer.sym} 2440 -2050 0 0 {name=x16}
C {devices/lab_pin.sym} 2290 -2030 0 0 {name=p310 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2290 -2070 0 0 {name=p311 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2590 -2070 0 1 {name=p312 sig_type=std_logic lab=V_GATE_BUF_0}
C {devices/lab_pin.sym} 2290 -2050 0 0 {name=p313 sig_type=std_logic lab=V_GATE_0}
C {devices/lab_pin.sym} 2290 -1970 0 0 {name=p314 sig_type=std_logic lab=V_GATE_1}
C {devices/lab_pin.sym} 2290 -1890 0 0 {name=p315 sig_type=std_logic lab=V_GATE_2}
C {devices/lab_pin.sym} 2290 -1810 0 0 {name=p316 sig_type=std_logic lab=V_GATE_3}
C {devices/lab_pin.sym} 2290 -1730 0 0 {name=p317 sig_type=std_logic lab=V_GATE_4
}
C {devices/lab_pin.sym} 2290 -1650 0 0 {name=p318 sig_type=std_logic lab=V_GATE_5
}
C {devices/lab_pin.sym} 2290 -1570 0 0 {name=p319 sig_type=std_logic lab=V_GATE_6
}
C {devices/lab_pin.sym} 2290 -1490 0 0 {name=p320 sig_type=std_logic lab=V_GATE_7
}
C {devices/lab_pin.sym} 2590 -1990 0 1 {name=p290 sig_type=std_logic lab=V_GATE_BUF_1}
C {devices/lab_pin.sym} 2590 -1910 0 1 {name=p291 sig_type=std_logic lab=V_GATE_BUF_2}
C {devices/lab_pin.sym} 2590 -1830 0 1 {name=p292 sig_type=std_logic lab=V_GATE_BUF_3}
C {devices/lab_pin.sym} 2590 -1750 0 1 {name=p302 sig_type=std_logic lab=V_GATE_BUF_4}
C {devices/lab_pin.sym} 2590 -1670 0 1 {name=p303 sig_type=std_logic lab=V_GATE_BUF_5}
C {devices/lab_pin.sym} 2590 -1590 0 1 {name=p304 sig_type=std_logic lab=V_GATE_BUF_6}
C {devices/lab_pin.sym} 2590 -1510 0 1 {name=p308 sig_type=std_logic lab=V_GATE_BUF_7}
C {devices/ipin.sym} 410 -1700 2 1 {name=p321 lab=HD_RES}
C {devices/ipin.sym} 410 -1730 2 1 {name=p322 lab=HD_SHORT}
C {devices/ipin.sym} 410 -1760 2 1 {name=p323 lab=HD_LINE}
C {buffer.sym} 1800 -1490 0 0 {name=x17}
C {buffer.sym} 1800 -1570 0 0 {name=x18}
C {buffer.sym} 1800 -1650 0 0 {name=x19}
C {devices/lab_pin.sym} 1650 -1470 0 0 {name=p324 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1650 -1550 0 0 {name=p325 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1650 -1630 0 0 {name=p326 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1650 -1510 0 0 {name=p327 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1650 -1590 0 0 {name=p328 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1650 -1670 0 0 {name=p329 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1950 -1670 0 1 {name=p330 sig_type=std_logic lab=HD_LINE_BUF}
C {devices/lab_pin.sym} 1950 -1590 0 1 {name=p331 sig_type=std_logic lab=HD_SHORT_BUF}
C {devices/lab_pin.sym} 1950 -1510 0 1 {name=p332 sig_type=std_logic lab=HD_RES_BUF}
C {devices/ipin.sym} 410 -1790 2 1 {name=p333 lab=VD_RES}
C {devices/ipin.sym} 410 -1820 2 1 {name=p334 lab=VD_SHORT}
C {devices/ipin.sym} 410 -1850 2 1 {name=p335 lab=VD_LINE}
C {buffer.sym} 1800 -1730 0 0 {name=x20}
C {buffer.sym} 1800 -1810 0 0 {name=x21}
C {buffer.sym} 1800 -1890 0 0 {name=x22}
C {devices/lab_pin.sym} 1650 -1710 0 0 {name=p336 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1650 -1790 0 0 {name=p337 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1650 -1870 0 0 {name=p338 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1650 -1750 0 0 {name=p339 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1650 -1830 0 0 {name=p340 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1650 -1910 0 0 {name=p341 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1950 -1910 0 1 {name=p342 sig_type=std_logic lab=VD_LINE_BUF
}
C {devices/lab_pin.sym} 1950 -1830 0 1 {name=p343 sig_type=std_logic lab=VD_SHORT_BUF}
C {devices/lab_pin.sym} 1950 -1750 0 1 {name=p344 sig_type=std_logic lab=VD_RES_BUF}
C {decoder_3bit.sym} 1160 -1540 0 0 {name=x23}
C {decoder_3bit.sym} 1160 -1780 0 0 {name=x24}
C {devices/lab_pin.sym} 1010 -1510 0 0 {name=p345 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1010 -1610 0 0 {name=p346 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1010 -1750 0 0 {name=p347 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1010 -1850 0 0 {name=p348 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1310 -1850 0 1 {name=p349 sig_type=std_logic lab=V_GATE_0}
C {devices/lab_pin.sym} 1310 -1830 0 1 {name=p350 sig_type=std_logic lab=V_GATE_1}
C {devices/lab_pin.sym} 1310 -1810 0 1 {name=p351 sig_type=std_logic lab=V_GATE_2}
C {devices/lab_pin.sym} 1310 -1790 0 1 {name=p352 sig_type=std_logic lab=V_GATE_3}
C {devices/lab_pin.sym} 1310 -1770 0 1 {name=p353 sig_type=std_logic lab=V_GATE_4
}
C {devices/lab_pin.sym} 1310 -1750 0 1 {name=p354 sig_type=std_logic lab=V_GATE_5
}
C {devices/lab_pin.sym} 1310 -1730 0 1 {name=p355 sig_type=std_logic lab=V_GATE_6
}
C {devices/lab_pin.sym} 1310 -1710 0 1 {name=p356 sig_type=std_logic lab=V_GATE_7
}
C {devices/lab_pin.sym} 1310 -1610 0 1 {name=p357 sig_type=std_logic lab=H_GATE_0}
C {devices/lab_pin.sym} 1310 -1590 0 1 {name=p358 sig_type=std_logic lab=H_GATE_1}
C {devices/lab_pin.sym} 1310 -1570 0 1 {name=p359 sig_type=std_logic lab=H_GATE_2}
C {devices/lab_pin.sym} 1310 -1550 0 1 {name=p360 sig_type=std_logic lab=H_GATE_3}
C {devices/lab_pin.sym} 1310 -1530 0 1 {name=p361 sig_type=std_logic lab=H_GATE_4}
C {devices/lab_pin.sym} 1310 -1510 0 1 {name=p362 sig_type=std_logic lab=H_GATE_5}
C {devices/lab_pin.sym} 1310 -1490 0 1 {name=p363 sig_type=std_logic lab=H_GATE_6}
C {devices/lab_pin.sym} 1310 -1470 0 1 {name=p364 sig_type=std_logic lab=H_GATE_7}
C {devices/lab_pin.sym} 1010 -1830 0 0 {name=p365 sig_type=std_logic lab=V_SEL_0}
C {devices/lab_pin.sym} 1010 -1810 0 0 {name=p366 sig_type=std_logic lab=V_SEL_1}
C {devices/lab_pin.sym} 1010 -1790 0 0 {name=p367 sig_type=std_logic lab=V_SEL_2}
C {devices/lab_pin.sym} 1010 -1770 0 0 {name=p368 sig_type=std_logic lab=SEL_EN}
C {devices/lab_pin.sym} 1010 -1590 0 0 {name=p369 sig_type=std_logic lab=H_SEL_0}
C {devices/lab_pin.sym} 1010 -1570 0 0 {name=p370 sig_type=std_logic lab=H_SEL_1}
C {devices/lab_pin.sym} 1010 -1550 0 0 {name=p371 sig_type=std_logic lab=H_SEL_2}
C {devices/lab_pin.sym} 1010 -1530 0 0 {name=p372 sig_type=std_logic lab=SEL_EN}
C {devices/lab_pin.sym} 1650 -1890 0 0 {name=p275 sig_type=std_logic lab=VD_LINE
}
C {devices/lab_pin.sym} 1650 -1810 0 0 {name=p276 sig_type=std_logic lab=VD_SHORT
}
C {devices/lab_pin.sym} 1650 -1730 0 0 {name=p277 sig_type=std_logic lab=VD_RES
}
C {devices/lab_pin.sym} 1650 -1650 0 0 {name=p293 sig_type=std_logic lab=HD_LINE
}
C {devices/lab_pin.sym} 1650 -1570 0 0 {name=p294 sig_type=std_logic lab=HD_SHORT
}
C {devices/lab_pin.sym} 1650 -1490 0 0 {name=p295 sig_type=std_logic lab=HD_RES
}
C {devices/ipin.sym} 410 -1670 2 1 {name=p305 lab=V_SEL_0}
C {devices/ipin.sym} 410 -1640 2 1 {name=p309 lab=V_SEL_1}
C {devices/ipin.sym} 410 -1610 2 1 {name=p373 lab=V_SEL_2}
C {devices/ipin.sym} 410 -1580 2 1 {name=p374 lab=H_SEL_0}
C {devices/ipin.sym} 410 -1550 2 1 {name=p375 lab=H_SEL_1}
C {devices/ipin.sym} 410 -1520 2 1 {name=p376 lab=H_SEL_2}
C {devices/ipin.sym} 410 -1490 2 1 {name=p377 lab=SEL_EN}
C {devices/iopin.sym} 410 -1460 2 0 {name=p378 lab=VSS}
C {devices/iopin.sym} 410 -1880 2 0 {name=p379 lab=VDD}
C {devices/iopin.sym} 470 -1880 2 1 {name=p380 lab=NODE_00}
C {devices/iopin.sym} 470 -1850 2 1 {name=p381 lab=NODE_04}
C {devices/iopin.sym} 470 -1820 2 1 {name=p382 lab=NODE_08}
C {devices/iopin.sym} 470 -1790 2 1 {name=p383 lab=NODE_40}
C {devices/iopin.sym} 470 -1760 2 1 {name=p384 lab=NODE_44}
C {devices/iopin.sym} 470 -1730 2 1 {name=p385 lab=NODE_48}
C {devices/iopin.sym} 470 -1700 2 1 {name=p386 lab=NODE_80}
C {devices/iopin.sym} 470 -1670 2 1 {name=p387 lab=NODE_84}
C {ignore.sym} 640 -1880 0 1 {name=l1}
C {devices/lab_pin.sym} 640 -1880 0 1 {name=p388 sig_type=std_logic lab=NODE_01}
C {ignore.sym} 640 -1860 0 1 {name=l2}
C {devices/lab_pin.sym} 640 -1860 0 1 {name=p389 sig_type=std_logic lab=NODE_02}
C {ignore.sym} 640 -1840 0 1 {name=l3}
C {devices/lab_pin.sym} 640 -1840 0 1 {name=p390 sig_type=std_logic lab=NODE_03}
C {ignore.sym} 640 -1820 0 1 {name=l4}
C {devices/lab_pin.sym} 640 -1820 0 1 {name=p391 sig_type=std_logic lab=NODE_05}
C {ignore.sym} 640 -1800 0 1 {name=l5}
C {devices/lab_pin.sym} 640 -1800 0 1 {name=p392 sig_type=std_logic lab=NODE_06}
C {ignore.sym} 640 -1780 0 1 {name=l6}
C {devices/lab_pin.sym} 640 -1780 0 1 {name=p393 sig_type=std_logic lab=NODE_07}
C {ignore.sym} 640 -1760 0 1 {name=l7}
C {devices/lab_pin.sym} 640 -1760 0 1 {name=p402 sig_type=std_logic lab=NODE_18}
C {ignore.sym} 640 -1740 0 1 {name=l8}
C {devices/lab_pin.sym} 640 -1740 0 1 {name=p406 sig_type=std_logic lab=NODE_28}
C {ignore.sym} 640 -1720 0 1 {name=l9}
C {devices/lab_pin.sym} 640 -1720 0 1 {name=p407 sig_type=std_logic lab=NODE_38}
C {ignore.sym} 640 -1700 0 1 {name=l10}
C {devices/lab_pin.sym} 640 -1700 0 1 {name=p408 sig_type=std_logic lab=NODE_58}
C {ignore.sym} 640 -1680 0 1 {name=l11}
C {devices/lab_pin.sym} 640 -1680 0 1 {name=p409 sig_type=std_logic lab=NODE_68}
C {ignore.sym} 640 -1660 0 1 {name=l12}
C {devices/lab_pin.sym} 640 -1660 0 1 {name=p410 sig_type=std_logic lab=NODE_78}
C {ignore.sym} 640 -1640 0 1 {name=l13}
C {devices/lab_pin.sym} 640 -1640 0 1 {name=p411 sig_type=std_logic lab=NODE_81}
C {ignore.sym} 640 -1620 0 1 {name=l14}
C {devices/lab_pin.sym} 640 -1620 0 1 {name=p412 sig_type=std_logic lab=NODE_82}
C {ignore.sym} 640 -1600 0 1 {name=l15}
C {devices/lab_pin.sym} 640 -1600 0 1 {name=p413 sig_type=std_logic lab=NODE_83}
C {ignore.sym} 640 -1580 0 1 {name=l16}
C {devices/lab_pin.sym} 640 -1580 0 1 {name=p414 sig_type=std_logic lab=NODE_85}
C {ignore.sym} 640 -1560 0 1 {name=l17}
C {devices/lab_pin.sym} 640 -1560 0 1 {name=p415 sig_type=std_logic lab=NODE_86}
C {ignore.sym} 640 -1540 0 1 {name=l18}
C {devices/lab_pin.sym} 640 -1540 0 1 {name=p416 sig_type=std_logic lab=NODE_87}
